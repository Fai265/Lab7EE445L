# Keil uVision project ADCPrintResults.uvproj, settings and files
target ADCPrintResults (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: ADCPrintResults
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s UART.c main.c ADCSWTrigger.c PLL.c Peltier.c WaterLevel.c LightSensor.c TemperatureSensor.c tm4c123gh6pm.h Peltier.h Fan.c Transistors.c Fan.h
    ../../ValvanoWareTM4C123/ESP8266_4C123/: FIFO.h
    ../../ESP8266_4C123/: esp8266.h esp8266.c
